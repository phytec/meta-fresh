# file autocreated by fresher
SRCREV = "031006a1bb0b65b9ab9d1fd6aefa9a8bc66722f7"
RT_PATCH_FILE = "patch-5.15.211-rt97.patch.xz"
SRC_URI[rt-patch.sha256sum] = "bbf35d21a2bfe00624d3219394bcac6e9f1b5575968699732d47f9e806bc3e5f"
PV = "5.15.216-phy"
